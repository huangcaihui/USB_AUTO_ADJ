# Keil uVision project usbd_hidfs_mschs.uvproj, settings and files
target STM322xG-EVAL_USBD-HS_FS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL_HS_FS
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c include: ..\;..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\audio\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ../src/: app.c usb_bsp.c usbd_usr.c usbd_storage_msd.c usbd_hid_desc.c usbd_msc_desc.c stm32fxxx_it.c
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group USB Device
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ../../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
    ../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_scsi.c usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c
  group USB Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd_int.c usb_core.c usb_dcd.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F2xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_sdio.c stm32f2xx_usart.c
  group STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_sdio_sd.c stm322xg_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
  group STM32F4xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM3240_41_G_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_sdio_sd.c stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c
  group Doc
    ../: readme.txt
target STM324xG-EVAL_USBD-HS_FS (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL_HS_FS +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c include: ..\;..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\audio\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\hid\inc;..\..\..\..\Libraries\STM32_USB_Device_Library\Class\msc\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
