# Keil uVision project USBH_DualCore.uvproj, settings and files
target STM322xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM322xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_STM322xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group App
    ../src/: stm32fxxx_it.c usb_bsp.c main.c dual_core_demo.c usbh_hid_usr.c usbh_msc_usr.c usbh_usr_lcd.c
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c
  group USB Host
    ../../../../Libraries/STM32_USB_HOST_Library/Class/HID/src/: usbh_hid_mouse.c usbh_hid_core.c usbh_hid_keybd.c
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_stdreq.c usbh_core.c usbh_hcs.c usbh_ioreq.c
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group FAT FS
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c fattime.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F2xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f2xx.s
    ../src/: system_stm32f2xx.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_syscfg.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_i2c.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_spi.c stm32f2xx_usart.c stm32f2xx_tim.c stm32f2xx_sdio.c
  group STM322xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_sdio_sd.c stm322xg_eval.c stm322xg_eval_ioe.c stm322xg_eval_lcd.c
  group STM32F4xx
    ../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
    ../src/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c
  group STM3240_41_G_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_sdio_sd.c stm324xg_eval.c stm324xg_eval_ioe.c stm324xg_eval_lcd.c
  group Doc
    ../: readme.txt
target STM324xG-EVAL_USBH-HS (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM324xG-EVAL
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY,USE_USB_OTG_FS
  c include: ..\inc;..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\..\Libraries\STM32_USB_OTG_Driver\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Core\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\MSC\inc;..\..\..\..\Libraries\STM32_USB_HOST_Library\Class\HID\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\..\Utilities\Third_Party\fat_fs\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
